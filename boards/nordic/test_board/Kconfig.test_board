## boards/nordic/test_board/board.yml
```yaml
board:
  name: test_board
  vendor: nordic
  socs:
  - name: nrf9151
    variants:
    - name: ns
```
